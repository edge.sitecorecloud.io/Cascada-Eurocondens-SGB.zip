Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2016-06-09T16:45:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.6.0.0 - Alternate UI 15.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 09 16:45:30 2016 * Host: Bestia-01 * Database: C:\Users\CARLOS~1\AppData\Local\Temp\{CA3C836B-E010-4CD2-9718-93361620984D}\ifc * Database version: 5507 * Database creation date: Thu Jun 09 16:45:30 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 09 16:45:30 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 09 16:45:30 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 23, 59, 999999; RefLongitude: -3, -40, -59, -879999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey, Nivel 1
LongName: Nivel 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Extremo inicial 8 mm; Family and Type: Level: Extremo inicial 8 mm; Type: Level: Extremo inicial 8 mm; Type Id: Level: Extremo inicial 8 mm
Identity Data - Type Name: Extremo inicial 8 mm; Building Story: yes; Name: Nivel 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Extremo inicial de nivel - Círculo: Extremo inicial de nivel - Círculo; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Eurocondens SGB 125, 2014_2-Calderas_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300-en-cascada:Eurocondens SGB 125:130529
In: Nivel 1
Type - Material: Aleación aluminio-silicio acabado pintura - Baxi, Cristal Display - Baxi, Display - Baxi
Type - Data - Capacidad agua: 0.029 m3; Longitud máx. evacuación de humos (m): 60 mm; Peso neto aproximado: 205; Potencia útil 50/30 ºC: 133100 W; Potencia útil 80/60 ºC: 121600 W; Presión máxima de trabajo: 600000 Pa; Rendimiento útil (1) con carga 100%: 1.065; Rendimiento útil (1) con carga 30%: 1.066; Rendimiento útil (2) con carga 100%: 0.973; Tipo de gas: natural/propano
Type - Dimensions - A-Espacio de Seguridad Recomendado: 600 mm; Altura caldera (mm): 1389 mm; Ancho caldera (mm): 692 mm; B-Espacio de Seguridad Recomendado: 500 mm; C-Espacio de Seguridad Recomendado (Derecha): 500 mm; C-Espacio de Seguridad Recomendado (Izquierda): 500 mm; D-Espacio de Seguridad Recomendado: 100 mm; Diametro Interior Entrada de Aire (mm): 110 mm; Diametro Interior Gas (mm): 28 mm; Diametro Interior IC-RC (mm): 65 mm; Diametro Interior Salida de Humos (mm): 160 mm; Diametro Interior Válvula Seguridad (mm): 28 mm; Largo caldera (mm): 1008 mm
Type - Identity Data - Autor: Bimetica Parametric Design Services S.L.; Bimetica: http://www.bimetica.com; Catálogo tarifa: http://www.baxi.es/docs/sp_cataleg/CatSept16_EuroCondens_SGB_gas.pdf/; Declaración de conformidad CE: http://www.baxi.es/docs/sp_decla/Decla_CE_Eurocondens_SGB.pdf; Description: Calderas de fundición de 125 kW de potencia útil, para instalaciones de Calefacción por agua caliente hasta 6 bar. Posibilidad integral de conexión doble en cascada homologada como un único generador.; EmailContacto: solutions@baxi.es; FechaEmisionElementoBIM: 04/05/2016; FechaVencimientoElementoBIM: 01/01/2017; Folleto media potencia: http://www.baxi.es/docs/sp_folleta/folleto_MediaPotencia2015.pdf; Homologación: http://www.baxi.es/docs/sp_homo/homo_eurocondensSGB.pdf; Manual Instalador: http://www.baxi.es/docs/sp_instruc/SGB125-300H.pdf; Manual Usuario: http://www.baxi.es/docs/sp_instruc/SGB125-300_H_BAXI.pdf; Manufacturer: Baxi Calefacción, S.L.U.; Model: 2 calderas Eurocondens SGB 125 en cascada; NumeroSerie: Eurocondens SGB; OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Referencia: 2 calderas Eurocondens SGB 125 en cascada; ReferenciaContacto: Departamento Técnico; TelefonoContacto: 902 89 89 89; Type Name: Eurocondens SGB 125; URL: www.baxi.es; URLProducto: http://www.baxi.es/docs/sp_folleta/Folleto_EuroCondens_SGB_2013_BAXI.pdf
Type - Materials and Finishes - Carcasa: Aleación aluminio-silicio acabado pintura - Baxi; Display: Display - Baxi; Pantalla: Cristal Display - Baxi; Requerimiento de Espacio Recomendado: Requerimiento Espacio Recomendado
Type - Mechanical - Flujo Entrada Aire: 0 m3/s; Flujo Gas: 0 m3/s; Flujo Humo: 0 m3/s; Flujo Ida - Agua: 0 m3/s; Flujo Retorno - Agua: 0 m3/s
Type - Other - Category: Mechanical Equipment; Altura Conexiones: 1444 mm; Altura Tubo F: 1444 mm; B: 280 mm; C: 301 mm; D-C: 702 mm; Diametro Exterior Gas: 38 mm; Diametro Exterior IC-RC: 75 mm; Diametro Exterior Válvula Seguridad: 38 mm; E: 122 mm; E-1: 302 mm; E-2: 134 mm; Family Name: 2014_2-Calderas_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300-en-cascada; F Exterior: 180 mm; G: 687 mm; H: 315 mm; I: 250 mm; K: 80 mm; L: 450 mm; M: 150 mm; N: 320 mm; SGB 125: yes; SGB 170: no; SGB 215: no; SGB 260: no; SGB 300: no; SGB 400: no; SGB 470: no; SGB 540: no; SGB 610: no; Situación Gas: 96 mm
Pset_BuildingElementProxyCommon - Reference: Eurocondens SGB 125
Pset_ManufacturerTypeInformation - Manufacturer: Baxi Calefacción, S.L.U.
Cantidades de equipos mecánicos - Descripción de unidad: 2014_2-Calderas_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300-en-cascada: Eurocondens SGB 125; Tipo: 2014_2-Calderas_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300-en-cascada: Eurocondens SGB 125; Descripción: Calderas de fundición de 125 kW de potencia útil, para instalaciones de Calefacción por agua caliente hasta 6 bar. Posibilidad integral de conexión doble en cascada homologada como un único generador.; Fabricante: Baxi Calefacción, S.L.U.; Modelo: 2 calderas Eurocondens SGB 125 en cascada; URL: www.baxi.es
Constraints - Host: Level : Nivel 1; Level: Level: Nivel 1; Offset: 0 mm
Dimensions - Area: 18.4618 m2; Separación Calderas en Cascada (mm): 50 mm; Volume: 1.94196 m3
Identity Data - Mark: 1
Mechanical - Espacio de Seguridad Recomendado: no; System Classification: Vent,Hydronic Supply,Hydronic Return,Other,Vent,Other,Hydronic Supply,Other,Vent,Other,Vent
Other - Family: 2014_2-Calderas_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300-en-cascada: Eurocondens SGB 125; Family and Type: 2014_2-Calderas_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300-en-cascada: Eurocondens SGB 125; Separación Calderas Control: 50 mm; Type: 2014_2-Calderas_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300-en-cascada: Eurocondens SGB 125; Type Id: 2014_2-Calderas_Baxi_de-Gas-de-Condensación-Eurocondens-SGB-125-300-en-cascada: Eurocondens SGB 125
Phasing - Phase Created: Fase 1
